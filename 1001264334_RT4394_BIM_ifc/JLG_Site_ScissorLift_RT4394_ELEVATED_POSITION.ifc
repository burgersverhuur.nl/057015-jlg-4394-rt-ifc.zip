Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-08-01T19:46:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 01 19:46:02 2024 * Host: CHTSW00749 * Database: C:\Users\40901979\AppData\Local\Temp\{4D5CDCF2-B7D0-47FF-8F2F-BCA43963F8C5}\ifc * Database version: 5507 * Database creation date: Thu Aug 01 19:45:31 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 01 19:45:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 01 19:45:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcTransportElement: JLG_Site_ScissorLift_RT4394, JLG_Site_ScissorLift_RT4394:JLG_Site_ScissorLift_RT4394:15159025
In: Level 1
Type - Material: JLG_Paint_Black, Yellow, White(WH), Black (BK), JLG_Metal Paint_White, JLG_Plastic_Yellow, JLG_Paint_Orange, JLG_Paint_Beige, BLACK, JLG_Rubber_Black, JLG_Steel
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - RT_ScissorLift; Manufacturer: JLG; ProductionYear: n/a
